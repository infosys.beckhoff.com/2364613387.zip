TYPE ST_PortAddr :
STRUCT
	portA : UINT;
	portB : UINT;
	portC : UINT;
	portD : UINT;
END_STRUCT
END_TYPE

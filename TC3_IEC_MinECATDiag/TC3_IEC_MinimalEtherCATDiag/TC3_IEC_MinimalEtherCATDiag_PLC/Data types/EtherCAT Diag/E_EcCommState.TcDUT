TYPE E_EcCommState : (
	eEcState_UNDEFINED 	:= 0,
	eEcState_INIT 		:= 1,
	eEcState_PREOP 		:= 2,
	eEcState_BOOT 		:= 3,
	eEcState_SAFEOP 	:= 4,
	eEcState_OP 		:= 8
);
END_TYPE

VAR_GLOBAL CONSTANT
	iSLAVEADDR_ARR_SIZE	: UDINT := 256;
END_VAR
